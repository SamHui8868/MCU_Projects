# Keil uVision project lab2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: lab2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Header files
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --libpath=C:\Keil_v5\ARM\ARMCC\lib
  group Source Group 1
    ./: main.c
  group CMSIS
    ./: myGPIO.c SevenSegmentAgent.c system_M451Series.c startup_M451Series.s myGPIO.h myM451Header.h SevenSegmentAgent.h
